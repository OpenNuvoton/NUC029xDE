# IAR project SPI_Loopback.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC029DE series Nuvoton NUC029DE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC029xDE\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_Loopback.bin
  ILINK.IlinkOutputFile: SPI_Loopback.out
  ILINK.IlinkIcfFile: SPI_Loopback.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xDE/Source/IAR/: startup_NUC029xDE.s
    ../../../../Library/Device/Nuvoton/NUC029xDE/Source/: system_NUC029xDE.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c spi.c uart.c
  group User
    ../: main.c
