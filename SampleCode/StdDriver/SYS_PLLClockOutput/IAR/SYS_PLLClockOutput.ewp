# IAR project SYS_PLLClockOutput.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC131AE series Nuvoton NUC131AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC029xDE\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SYS_PLLClockOutput.bin
  ILINK.IlinkOutputFile: SYS_PLLClockOutput.out
  ILINK.IlinkIcfFile: SYS_PLLClockOutput.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xDE/Source/IAR/: startup_NUC029xDE.s
    ../../../../Library/Device/Nuvoton/NUC029xDE/Source/: system_NUC029xDE.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../: main.c
