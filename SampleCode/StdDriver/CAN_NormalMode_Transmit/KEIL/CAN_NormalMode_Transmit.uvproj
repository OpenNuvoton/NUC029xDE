# Keil uVision project CAN_NormalMode_Transmit.uvproj, settings and files
target CAN_NormalMode_Transmit (ARM-ADS)
  device: NUC029SDE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: CAN_NormalMode_Transmit
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC029xDE\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC029xDE.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../Library/Device/Nuvoton/NUC029xDE/Source/: system_NUC029xDE.c
    ../../../../Library/Device/Nuvoton/NUC029xDE/Source/ARM/: startup_NUC029xDE.s
  group Source files
    ../: main.c
  group Library files
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c can.c
