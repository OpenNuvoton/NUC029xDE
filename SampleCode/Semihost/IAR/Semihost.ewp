# IAR project Semihost.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC131AE series Nuvoton NUC131AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; DEBUG_ENABLE_SEMIHOST=1
  ICCARM.CCIncludePath2: ..\..\..\Library\CMSIS\Include; ..\..\..\Library\Device\Nuvoton\NUC029xDE\Include; ..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG_ENABLE_SEMIHOST
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: Semihost.bin
  ILINK.IlinkOutputFile: Semihost.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC029xDE/Source/IAR/: startup_NUC029xDE.s
    ../../../Library/Device/Nuvoton/NUC029xDE/Source/: system_NUC029xDE.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c
  group User
    ../: main.c
