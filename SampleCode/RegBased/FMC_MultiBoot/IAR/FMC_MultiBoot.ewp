# IAR project FMC_MultiBoot.ewp, settings and files
configuration FMC_MultiBoot (ARM)
  General.OGChipSelectEditMenu: NUC029DE series Nuvoton NUC029DE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC029xDE\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: FMC_MultiBoot.bin
  ILINK.IlinkOutputFile: FMC_MultiBoot.out
  ILINK.IlinkIcfFile: FMC_MultiBoot.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration FMC_Boot0 (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  OBJCOPY.OOCOutputFile: FMC_Boot0.bin
  ILINK.IlinkOutputFile: FMC_Boot0.out
  ILINK.IlinkIcfFile: FMC_Boot0.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FMC_Boot1 (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  OBJCOPY.OOCOutputFile: FMC_Boot1.bin
  ILINK.IlinkOutputFile: FMC_Boot1.out
  ILINK.IlinkIcfFile: FMC_Boot1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FMC_Boot2 (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  OBJCOPY.OOCOutputFile: FMC_Boot2.bin
  ILINK.IlinkOutputFile: FMC_Boot2.out
  ILINK.IlinkIcfFile: FMC_Boot2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FMC_Boot3 (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  OBJCOPY.OOCOutputFile: FMC_Boot3.bin
  ILINK.IlinkOutputFile: FMC_Boot3.out
  ILINK.IlinkIcfFile: FMC_Boot3.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xDE/Source/IAR/: startup_NUC029xDE.s
    ../../../../Library/Device/Nuvoton/NUC029xDE/Source/: system_NUC029xDE.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c
  group User
    ../: main.c
