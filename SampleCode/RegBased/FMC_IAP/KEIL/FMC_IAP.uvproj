# Keil uVision project FMC_IAP.uvproj, settings and files
target FMC_IAP_LD (6160000::V6.16::ARMCLANG)
  device: NUC029SDE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FMC_IAP_LD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC029xDE\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_NUC029xDE.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xDE/Source/: system_NUC029xDE.c
    ../../../../Library/Device/Nuvoton/NUC029xDE/Source/ARM/: startup_NUC029xDE.s
  group User
    ../: main.c LoaderImage.s main_LD.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c
target FMC_IAP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: NUC029SDE Nuvoton
  cpu: as above
  output: FMC_IAP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: as above
