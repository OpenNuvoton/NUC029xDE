# IAR project CAN_Test_MaskFilter.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC029DE series Nuvoton NUC029DE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC029xDE\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CAN_Test_MaskFilter.bin
  ILINK.IlinkOutputFile: CAN_Test_MaskFilter.out
  ILINK.IlinkIcfFile: CAN_Test_MaskFilter.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS Files
    ../../../../Library/Device/Nuvoton/NUC029xDE/Source/IAR/: startup_NUC029xDE.s
    ../../../../Library/Device/Nuvoton/NUC029xDE/Source/: system_NUC029xDE.c
  group Library Files
    ../../../../Library/StdDriver/src/: retarget.c
  group Source Files
    ../: main.c
